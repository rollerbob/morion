# IAR project morion_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L011K4 ST STM32L011K4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: core\inc; CMSIS\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: morion_test.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: startup\stm32l011xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS/inc
    CMSIS/inc/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h stm32l011xx.h stm32l0xx.h system_stm32l0xx.h
  group CMSIS/src
    CMSIS/src/: system_stm32l0xx.c
  group core/inc
    core/inc/: defines.h led_control.h main.h parser.h usart_control.h
  group core/src
    core/src/: led_control.c main.c parser.c usart_control.c
  group Startup
    startup/: startup_stm32l011xx.s
